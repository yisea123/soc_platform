# IAR project firmware_platform2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M2S005 Microsemi M2S005
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USB_BAREMETAL
  ICCARM.CCIncludePath2: ../../hw_platform/hal; ../../hw_platform/hal/CortexM3; ../../hw_platform/hal/CortexM3/EWARM; ../../hw_platform/CMSIS; ../../hw_platform/CMSIS/startup_iar; ../../hw_platform/drivers/mss_gpio; ../../hw_platform/drivers/mss_hpdma; ../../hw_platform/drivers/mss_i2c; ../../hw_platform/drivers/mss_nvm; ../../hw_platform/drivers/mss_pdma; ../../hw_platform/drivers/mss_rtc; ../../hw_platform/drivers/mss_spi; ../../hw_platform/drivers/mss_rtc; ../../hw_platform/drivers/mss_sys_services; ../../hw_platform/drivers/mss_timer; ../../hw_platform/drivers/mss_uart; ../../hw_platform/drivers/mss_usb; ../../hw_platform/drivers/mss_watchdog; ../../hw_platform/drivers/CoreGPIO; ../../hw_platform/drivers/CorePWM; ../../hw_platform/drivers_config/sys_config; ../../include; ../../fw_platform; ../../fw_platform/fpga; ../../fw_platform/motor; ../../fw_platform/nvram; ../../fw_platform/sensor; ../../fw_platform/scanunit; ../../FreeRTOS/include; ../../FreeRTOS/portable/IAR/ARM_CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: firmware_platform.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USB_BAREMETAL
  ICCARM.CCIncludePath2: ../../hw_platform; ../../hw_platform/hal; ../../hw_platform/hal/CortexM3; ../../hw_platform/hal/CortexM3/EWARM; ../../hw_platform/CMSIS; ../../hw_platform/CMSIS/startup_iar; ../../hw_platform/drivers/mss_gpio; ../../hw_platform/drivers/mss_hpdma; ../../hw_platform/drivers/mss_i2c; ../../hw_platform/drivers/mss_nvm; ../../hw_platform/drivers/mss_pdma; ../../hw_platform/drivers/mss_rtc; ../../hw_platform/drivers/mss_spi; ../../hw_platform/drivers/mss_rtc; ../../hw_platform/drivers/mss_sys_services; ../../hw_platform/drivers/mss_timer; ../../hw_platform/drivers/mss_uart; ../../hw_platform/drivers/mss_usb; ../../hw_platform/drivers/mss_watchdog; ../../hw_platform/drivers/CoreGPIO; ../../hw_platform/drivers/CorePWM; ../../hw_platform/drivers_config/sys_config; ../../include; ../../fw_platform; ../../fw_platform/fpga; ../../fw_platform/motor; ../../fw_platform/nvram; ../../fw_platform/sensor; ../../fw_platform/scanunit; ../../FreeRTOS/include; ../../FreeRTOS/portable/IAR/ARM_CM3
  ICCARM.CCOptLevel: 3
  group (top)
    ../../fw_platform/: fpga.h fpga_io.h
  group fpga
    ../../fw_platform/fpga/: fpga.c fpga_adc.c fpga_adc.h fpga_gpio.c fpga_gpio.h fpga_irqmux.c fpga_irqmux.h fpga_pwm.c fpga_pwm.h
  group gpiokey
    ../../fw_platform/gpiokey/: gpiokey.c gpiokey.h
  group include
    ../../include/: irqcallback.h motor.h nvmapi.h pwm.h sensor.h
  group mechanism
    ../../../../platform/fw_platform/mechanism/: mech_motor2.c mech_motor2.h mech_sensor2.c mech_sensor2.h mech_unit2.c mech_unit2.h
  group motor
    ../../fw_platform/motor/: dcmotor.c dcmotor.h fpga_stepmotor.c fpga_stepmotor.h steppermotor.c steppermotor.h steptable.h
    ../../../../platform/fw_platform/motor/: fpga_dcmotor_controller.c fpga_dcmotor_controller.h fpga_stepmotor_controller.c fpga_stepmotor_controller.h fpga_timer.c fpga_timer.h
  group nvram
    ../../fw_platform/nvram/: at24cxx.c at24cxx.h mt5ql128aba.c nvmapi.c nvram.c nvram.h s25fl128p.c socnvm.c socnvm.h spiflash.c spiflash.h w25q16jv.c w25q32jv.c
  group scanunit
    ../../fw_platform/scanunit/: fpga_cis.c fpga_cis.h imagedigitiser.c imagedigitiser.h imagesensor.c imagesensor.h scanunit.c scanunit.h wm8215.c wm8215.h
  group sensor
    ../../fw_platform/sensor/: adc.c adc.h fpga_photosensor.c fpga_photosensor.h fpga_simplesensor.c fpga_simplesensor.h gpio_photosensor.c gpio_photosensor.h gpio_simplesensor.c gpio_simplesensor.h photosensor.c photosensor.h simplesensor.c simplesensor.h
  group usbd
    ../../fw_platform/usbd/: mss_usb_device_vendor.c mss_usb_device_vendor.h usb_user_descriptors.c usbd_driver.c
  group utility
    ../../fw_platform/utility/: crc32.c
