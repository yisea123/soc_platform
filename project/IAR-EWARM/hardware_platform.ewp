# IAR project hardware_platform.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M2S005 Microsemi M2S005
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ../../hw_platform; ../../hw_platform/hal; ../../hw_platform/hal/CortexM3; ../../hw_platform/hal/CortexM3/EWARM; ../../hw_platform/CMSIS; ../../hw_platform/CMSIS/startup_iar; ../../hw_platform/drivers/mss_gpio; ../../hw_platform/drivers/mss_hpdma; ../../hw_platform/drivers/mss_i2c; ../../hw_platform/drivers/mss_nvm; ../../hw_platform/drivers/mss_pdma; ../../hw_platform/drivers/mss_rtc; ../../hw_platform/drivers/mss_spi; ../../hw_platform/drivers/mss_rtc; ../../hw_platform/drivers/mss_sys_services; ../../hw_platform/drivers/mss_timer; ../../hw_platform/drivers/mss_uart; ../../hw_platform/drivers/mss_usb; ../../hw_platform/drivers/mss_watchdog; ../../hw_platform/drivers/CoreGPIO; ../../hw_platform/drivers/CorePWM; ../../hw_platform/drivers/CoreSPI
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: hardware_platform.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../hw_platform/CMSIS/startup_iar/: default_irqs.c low_level_init.c read.c startup_m2sxxx.s vector_table.c write.c
    ../../hw_platform/CMSIS/: system_m2sxxx.c
  group driver_config
    ../../hw_platform/drivers_config/sys_config/: sys_config.c sys_config.h sys_config_mss_clocks.h
  group drivers
    ../../hw_platform/drivers/CoreGPIO/: core_gpio.c
    ../../hw_platform/drivers/CorePWM/: core_pwm.c
    ../../hw_platform/drivers/CoreSPI/: core_spi.c
    ../../hw_platform/drivers/mss_gpio/: mss_gpio.c
    ../../hw_platform/drivers/mss_hpdma/: mss_hpdma.c
    ../../hw_platform/drivers/mss_i2c/: mss_i2c.c
    ../../hw_platform/drivers/mss_nvm/: mss_nvm.c
    ../../hw_platform/drivers/mss_pdma/: mss_pdma.c
    ../../hw_platform/drivers/mss_rtc/: mss_rtc.c
    ../../hw_platform/drivers/mss_spi/: mss_spi.c
    ../../hw_platform/drivers/mss_sys_services/: mss_sys_services.c
    ../../hw_platform/drivers/mss_uart/: mss_uart.c
    ../../hw_platform/drivers/mss_usb/: mss_usb_common_cif.c mss_usb_device.c mss_usb_device_cif.c
  group hal
    ../../hw_platform/hal/CortexM3/: cortex_nvic.c
    ../../hw_platform/hal/CortexM3/EWARM/: hal.s hw_reg_access.s
