# IAR project freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M2S005 Microsemi M2S005
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ../../include; ../../FreeRTOS/include; ../../FreeRTOS/portable/IAR/ARM_CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\include
  ILINK.IlinkOutputFile: freertos.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../../include/: FreeRTOSConfig.h
  group include
    ../../FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group portable
    ../../FreeRTOS/portable/MemMang/: heap_2.c
    ../../FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s
